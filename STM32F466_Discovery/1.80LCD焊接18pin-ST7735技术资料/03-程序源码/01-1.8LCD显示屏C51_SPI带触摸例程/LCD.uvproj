# Keil uVision project LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SRC\LED;.\SRC\LCD;.\SRC\TOUCH
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./SRC/LCD/: lcd_init.c lcd.c
    ./SRC/TOUCH/: touch.c
