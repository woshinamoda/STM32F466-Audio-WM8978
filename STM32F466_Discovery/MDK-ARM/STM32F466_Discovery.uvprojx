# Keil uVision project STM32F466_Discovery.uvprojx, settings and files
target STM32F466_Discovery (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F446RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F466_Discovery +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F446xx
  c include: ../Core/Inc;        ../Drivers/STM32F4xx_HAL_Driver/Inc;        ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;        ../Drivers/CMSIS/Include;        ../uAPP;        ../FATFS/Target;        ../FATFS/App;        ../Middlewares/Third_Party/FatFs/src;        ../TouchGFX/App;        ../TouchGFX/target/generated;        ../TouchGFX/target;        ../uFatFs;        ../uAEP;      ../middlewares/st/touchgfx/framework/include;      ../touchgfx/generated/fonts/include;      ../touchgfx/generated/gui_generated/include;      ../touchgfx/generated/images/include;      ../touchgfx/generated/texts/include;      ../touchgfx/generated/videos/include;      ../touchgfx/gui/include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group uAPP
    ../uAPP/: system_st7735.c system_led.c system_key.c
  group uAudio
    ../uAPP/: audio_wm8978_I2C.c system_exfuns.c system_malloc.c system_wavplay.c
  group uAEP_AFMDriver
    ../uAEP/: Output_AEP.c
  group uFEM
    ../uAPP/: system_FEM.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c dac.c dma.c i2c.c i2s.c quadspi.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_qspi.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group gui
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screen_screen/: screenpresenter.cpp screenview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_dengb_15_2bpp_0.cpp font_dengb_15_2bpp_10.cpp font_dengb_15_2bpp_11.cpp font_dengb_15_2bpp_13.cpp font_dengb_15_2bpp_14.cpp font_dengb_15_2bpp_18.cpp font_dengb_15_2bpp_19.cpp font_dengb_15_2bpp_31.cpp font_verdana_20_2bpp_0.cpp font_verdana_40_2bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_dengb_15_2bpp.cpp kerning_verdana_20_2bpp.cpp kerning_verdana_40_2bpp.cpp table_dengb_15_2bpp.cpp table_verdana_20_2bpp.cpp table_verdana_40_2bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp languagemedium_text.cpp languagemedium_title.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/screen_screen/: screenviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group doc
    ../: Readme.txt
software components: CMSIS:CORE 4.3.0
